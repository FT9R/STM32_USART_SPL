# IAR project UART SPL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: Config; Include; Source; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\STM32F4xx_StdPeriph_Driver\src; Libraries\USART
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Config
    Config/: startup_stm32f407xx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group Include
    Include/: main.h Sys_Init.h
  group Libraries/STM32F4xx_StdPeriph_Driver/inc
    Libraries/STM32F4xx_StdPeriph_Driver/inc/: stm32f4xx_rcc.h stm32f4xx_usart.h
  group Libraries/STM32F4xx_StdPeriph_Driver/src
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_usart.c
  group Libraries/USART
    Libraries/USART/: USART.c USART.h
  group Source
    Source/: main.c Sys_Init.c
